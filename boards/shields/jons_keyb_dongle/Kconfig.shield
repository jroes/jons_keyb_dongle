## boards/shields/jons_keyb_dongle/Kconfig.shield
```kconfig
config SHIELD_JONS_KEYB_DONGLE
    def_bool $(shields_list_contains,jons_keyb_dongle)
```
